# Keil uVision project Camera and uc_gui_2.0.uvprojx, settings and files
target UCOS_UCGUI (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ygowill +hex
  AfterMake: fromelf.exe --bin -o ygowill.bin ..\Output\ygowill.axf
  c flags: oTime=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\code\header;..\code\library\inc;..\..\include;..\..\..\..\library\inc;..\..\..\..\..\FWLib\library\inc;..\code\FAT16;..\code\driver;..\code\ffs;..\code\TFT;..\code\OV7670;..\code\TFT;..\code\menu;..\code\TFT\TFT_ILI9328;..\code\RTC;..\code\user;..\code\GUI\Config;..\code\ADC;..\FWlib\inc;..\code\GUI\GUI_inc;..\code\GPS;..\code\GUI_4.04\Include;..\code\PS2;..\code\driver\delay;..\code\application;..\code\UCOSII\PORTS;..\code\UCOSII\SOURCE;..\code\Calculator;..\code\uCGUI\AntiAlias;..\code\uCGUI\ConvertColor;..\code\uCGUI\ConvertMono;..\code\uCGUI\Core;..\code\uCGUI\Font;..\code\uCGUI\MemDev;..\code\uCGUI\MultiLayer;..\code\uCGUI\Widget;..\code\uCGUI\WM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group system
    ../code/system/: stm32f10x_it.c startup_stm32f10x_xl.s
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group ADC
    ../code/ADC/: ADC.C
  group user
    ../code/user/: main.c ucGUI_Practice.c main.h
    ../code/GUI/: GUI_X.c
  group APPLICATION
    ../code/GUI/: mylib.lib
    ../code/application/: app.c app_cfg.h os_cfg.h MyCalculator V1.0.c AboutFrame.c
  group TFT
    ../code/TFT/TFT_ILI9328/: ILI9325.c
    ../code/TFT/: lcm_api.c touch.c
  group driver
    ../code/driver/: SysConfig.c uart.c delay.c
  group FWLib
    ../FWlib/src/: stm32f10x_adc.c stm32f10x_gpio.c stm32f10x_rtc.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_bkp.c misc.c stm32f10x_pwr.c stm32f10x_fsmc.c
  group LCDDriver
    ../code/GUI/LCDDriver/: LCDNull.c
  group UCOS/PORT
    ../code/UCOSII/PORTS/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group UCOS/SOURCE
    ../code/UCOSII/SOURCE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
  group Calculator
    ../code/Calculator/: calculator.c calculator.h stack.c stack.h fpconv.c
software components: CMSIS:CORE 5.1.1
